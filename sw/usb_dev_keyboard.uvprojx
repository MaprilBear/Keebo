# Keil uVision project usb_dev_keyboard.uvprojx, settings and files
target usb_dev_keyboard (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: usb_dev_keyboard
  AfterMake: fromelf --bin --output .\rvmdk\usb_dev_keyboard.bin .\rvmdk\usb_dev_keyboard.axf
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 UART_BUFFERED
  c include: C:\ti\TivaWare_C_Series-2.2.0.295
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\usb_dev_keyboard.sct
  link misc: --entry Reset_Handler
  group Source
    C:/ti/TivaWare_C_Series-2.2.0.295/utils/: uartstdio.c
    ./: usb_keyb_structs.c Switch_Matrix.c Switch_Matrix.h startup_rvmdk.S App_BongoCat.c Bootloader.c main.c Helpers.c Keyboard.c App_Clock.c App_Clock.h
    ./drivers/: buttons.c rgb.c
    ./inc/: ST7735.c
  group Libraries
    C:/ti/TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
    C:/ti/TivaWare_C_Series-2.2.0.295/usblib/rvmdk/: usblib.lib
  group Documentation
    ./: readme.txt
  group Include
    ./inc/: Timer0A.c CortexM.c Timer1A.c Timer2A.c PLL.c UART5.c UART.c UART1.c Timer3A.c Timer3A.h
software components: CMSIS:CORE 5.6.0
